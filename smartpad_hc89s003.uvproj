# Keil uVision project smartpad_hc89s003.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: smartpad_hc89s003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_HC89S_CORE
  c include: ./inc
  asm include: ./inc
  group sys
    ./: STARTUP.A51
  group usr
    ./src/: main.c hc89s003_clk.c mcu_config.c hc89s003_delay.c hc89s003_gpio.c hc89s003_wdt.c hc89s003_timer3.c tick.c fm1906.c hc89s003_pwm.c hc89s003_adc.c board.c hc89s003_uart.c hc89s003_flash.c comm.c display_driver.c beep.c alarm.c display.c key.c warning.c ht1621.c led.c
